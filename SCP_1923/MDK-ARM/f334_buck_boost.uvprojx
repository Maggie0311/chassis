# Keil uVision project f334_buck_boost.uvprojx, settings and files
target f334_buck_boost (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F334C8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x10000000-0x10000FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: f334_buck_boost +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F334x8,__TARGET_FPU_VFP,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1U,__TARGET_FPU_VFP,__FPU_USED=1U,__ARM_FEATURE_DSP=1,USE_FULL_LL_DRIVER
  c include: ../Core/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Drivers/CMSIS/Include;../UserCode;../UserCode/Time;../UserCode/PowerCtrl;../UserCode/NTC;../UserCode/Monitor;../UserCode/GeneralCtrl;../UserCode/Communication;../UserCode/ADCSense;../UserCode/Tool
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  scatter file: stm32f334xx_flash.sct
  group UserCode/Time
    ../UserCode/Time/: drv_Time.c
  group UserCode/ADCSense
    ../UserCode/ADCSense/: drv_ADCSense.c drv_utils.c mod_ADCProcess.c
  group UserCode/PowerCtrl
    ../UserCode/PowerCtrl/: drv_BridgeHW.c drv_BridgeMath.c func_ChargeSafety.c func_CurrentCtrl.c func_PowerCtrl.c pid.c func_Observer.c drv_SetPlanning.c func_SafetyProtect.c
  group UserCode/NTC
    ../UserCode/NTC/: drv_NTCSensor.c mod_NTCSensor.c
  group UserCode/Monitor
    ../UserCode/Monitor/: drv_CPUUsage.c drv_LinkedList.c drv_Monitor.c func_LED.c
  group UserCode/GeneralCtrl
    ../UserCode/GeneralCtrl/: app_Routine.c
  group UserCode/Communication
    ../UserCode/Communication/: drv_CAN.c drv_Queue.c drv_TrigRec.c
  group Application/MDK-ARM
    ./: startup_stm32f334x8.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c hrtim.c iwdg.c tim.c usart.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_utils.c stm32f3xx_ll_exti.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_ll_rcc.c stm32f3xx_hal_can.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_iwdg.c stm32f3xx_ll_tim.c stm32f3xx_ll_gpio.c stm32f3xx_ll_dma.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
  group UserCode/Tool
    ../UserCode/Tool/: func_Sense.c
software components: CMSIS:CORE 5.2.0, CMSIS:DSP 1.6.0
